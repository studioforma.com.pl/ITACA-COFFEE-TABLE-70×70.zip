Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Itaca-Coffee table 70x70 - ver4.ifc
Time: 2025-11-13T16:06:53
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Itaca-Coffee table 70x70_0 - ObjectType: SketchupGroup
 | Itaca-Coffee table 70x70_1 - ObjectType: SketchupGroup
 | Itaca-Coffee table 70x70_2 - ObjectType: SketchupGroup
 | Itaca-Coffee table 70x70_3 - ObjectType: SketchupGroup
 | Itaca-Coffee table 70x70_4 - ObjectType: SketchupGroup
 | Itaca-Coffee table 70x70_5 - ObjectType: SketchupGroup
 | Itaca-Coffee table 70x70_6 - ObjectType: SketchupGroup
 | Itaca-Coffee table 70x70_7 - ObjectType: SketchupGroup
